## dts/bindings/zmk,behavior-usb-fp-type.yaml
```yaml
description: USB host fingerprint capture typing behavior

compatible: "zmk,behavior-usb-fp-type"

include: zero_param.yaml
```
